# Keil uVision project GD32F470VE.uvprojx, settings and files
target GD32F470VET6_Project (6230000::V6.23::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x0800D000,0x038000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: cmd /c call .\make_app_bin.bat & exit /b 0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\common;..\Core\Inc;..\App\Inc;..\Bsp\Inc;..\Components\gd30ad3344;..\Components\oled;..\Components\gd25qxx;..\Components\ring_buffer;..\Firmware\GD32F4xx_standard_peripheral\Include;..\.cmsis\include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x800d000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: app.c adc_app.c btn_app.c led_app.c oled_app.c rtc_app.c param_app.c scheduler.c dac_app.c uart0_app.c rs485_app.c command_app.c pt100_app.c pt100_convert.c ota_app.c low_power_app.c
  group Core
    ../Core/Src/: main.c systick.c gd32f4xx_it.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Bsp
    ../Bsp/Src/: adc_bsp.c dac_bsp.c uart0_bsp.c rs485_bsp.c rtc_bsp.c btn_bsp.c led_bsp.c oled_bsp.c low_power_bsp.c flash_bsp.c gd30_bsp.c ota_bsp.c onchip_flash_bsp.c
  group Components/gd25qxx
    ../Components/gd25qxx/: gd25qxx.c
  group Components/gd30ad3344
    ../Components/gd30ad3344/: gd30ad3344.c
  group Components/oled
    ../Components/oled/: oled.c oledfont.c
  group Components/ring_buffer
    ../Components/ring_buffer/: ring_buffer.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_dac.c gd32f4xx_dma.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_usart.c gd32f4xx_fmc.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
software components: CMSIS:CORE 6.1.0
