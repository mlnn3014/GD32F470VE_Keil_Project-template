# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader_F470 (6230000::V6.23::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x00C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Core\Inc;..\App\Inc;..\Bsp\Inc;..\Project\RTE\_BootLoader_F470;..\..\common;..\..\Bsp\Inc;..\..\Core\Inc;..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\.cmsis\include;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: bootloader_app.c
  group Core
    ../Core/Src/: main.c gd32f4xx_it.c
    ../../Core/Src/: systick.c
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Bsp
    ../Bsp/Src/: boot_uart_bsp.c
    ../../Bsp/Src/: onchip_flash_bsp.c
  group Firmware
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_usart.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
software components: CMSIS:CORE 6.1.0
