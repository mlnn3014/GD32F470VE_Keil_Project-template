# Keil uVision project Project.uvprojx, settings and files
target McuSTUDIO_F470VET6 (6230000::V6.23::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08011000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\HeaderFiles\common;..\Library\GD32F4xx_standard_peripheral\Include;..\HeaderFiles\User;..\CMSIS\Driver\CMSIS_5\CMSIS\Core\Include;..\CMSIS\Driver\CMSIS;..\CMSIS\Driver\CMSIS\GD\GD32F4xx\Include;..\Driver;..\HardWare\bsp;..\Protocol\ota_uart;..\Protocol\cimc;..\HardWare\ringbuffer;..\HardWare\gd30ad3344;..\HardWare\oled;..\HardWare\gd25qxx;..\HardWare\ebtn;..\Function;..\Library\Third_Party\perf_counter-2.3.3
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\App_F470.sct
  group System
    ../System/src/: gd32f4xx_it.c main.c systick.c
  group HeaderFiles/common
    ../HeaderFiles/common/: bl_param.h bl_partition.h ota_package_config.h
  group HardWare/bsp
    ../HardWare/bsp/: mcu_cimc_gd32f470vet6.c mcu_cimc_gd32f470vet6.h
  group Driver
    ../Driver/: driver_rs485.c driver_rs485.h
  group Protocol/ota_uart
    ../Protocol/ota_uart/: ota_uart.c ota_uart.h ota_protocol.h
  group Protocol/cimc
    ../Protocol/cimc/: cimc_ascii_hex.c cimc_ascii_hex.h cimc_crc16.c cimc_crc16.h cimc_frame.c cimc_frame.h cimc_protocol_defs.h
  group HardWare/gd25qxx
    ../HardWare/gd25qxx/: gd25qxx.c lfs.c lfs_port.c lfs_util.c
  group HardWare/gd30ad3344
    ../HardWare/gd30ad3344/: gd30ad3344.c gd30ad3344.h
  group HardWare/oled
    ../HardWare/oled/: oled.c
  group HardWare/ebtn
    ../HardWare/ebtn/: ebtn.c ebtn.h
  group HardWare/ringbuffer
    ../HardWare/ringbuffer/: ring_buffer.c ring_buffer.h
  group Function
    ../Function/: btn_app.c cimc_app.c cimc_app.h led_app.c oled_app.c scheduler.c usart_app.c adc_app.c flash_fs_app.c rtc_app.c
  group Library/GD32F4xx_standard_peripheral/Source
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library/Third_Party/perf_counter
    ../Library/Third_Party/perf_counter-2.3.3/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
