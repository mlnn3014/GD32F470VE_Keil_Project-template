# Keil uVision project Project.uvprojx, settings and files
target McuSTUDIO_F470VET6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\HeaderFiles\common;..\Library\GD32F4xx_standard_peripheral\Include;..\HeaderFiles\User;..\CMSIS\Driver\CMSIS\GD\GD32F4xx\Include;..\HardWare\bsp;..\HardWare\ringbuffer;..\HeaderFiles\BootLoader;..\Function;E:\keil\Pack\ARM\CMSIS\5.7.0\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BootLoader_F470.sct
  group System
    ../System/src/: gd32f4xx_it.c main.c systick.c
  group HeaderFiles/common
    ../HeaderFiles/common/: bl_param.h bl_partition.h
  group Protocol/bootloader
    ../Protocol/bootloader/: bl_core.c
  group HardWare/bsp
    ../HardWare/bsp/: mcu_cimc_gd32f470vet6.c mcu_cimc_gd32f470vet6.h
  group HardWare/ringbuffer
    ../HardWare/ringbuffer/: ring_buffer.c ring_buffer.h
  group Function
    ../Function/: usart_app.c
  group Library/GD32F4xx_standard_peripheral
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_fmc.c gd32f4xx_dma.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 6.1.1
