# Keil uVision project Project.uvprojx, settings and files
target GD32F303C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,GD32F303
  c include: ..\..\Utilities\GD32F30x_Firmware_Library\CMSIS;..\..\Utilities\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\Utilities\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\Utilities\Port\Include;..\..\Project;..\..\GD30AD3344_Firmware_Library\GD30AD3344_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: systick.c gd32f30x_it.c main.c
  group GD30AD3x4x_Library
    ../../GD30AD3344_Firmware_Library/GD30AD3344_standard_peripheral/Source/: gd30ad3344.c
  group Port
    ../../Utilities/Port/Source/: spi_port.c uart_print.c
  group Utilities
    ../../Utilities/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../Utilities/GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../../Utilities/GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_usart.c
  group Doc
    ../../Doc/: readme.txt
